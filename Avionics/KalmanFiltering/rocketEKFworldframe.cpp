#include "ExtendedKalmanFilter.hpp"
#include <random>
#include <iostream>
#include <fstream>
#include <string>
#include <sstream>
#include "../csvWriter.hpp"
// #include "../Rocket_Simulation/RotationMatrices.hpp"

// Define DragEntry struct before using it
struct DragEntry {
    double mach;
    double cd;
    double cnalpha;
};

// Utility functions (parseDragCSV, lookupDrag, etc.) should be here
// ...existing code...

// Global variables (only one set, no duplicates)
double gravity = 9.80665;
double area =  0.01824146924;
const double T0 = 288.15; // K
const double P0 = 101325.0;
double gamma0 = 1.4;
const double R_air = 287.05;
double mass0 = 49.5;
double rho0 = 1.225;
const double L = 0.0065;
double dt = 0.001;
std::vector<std::vector<double>> x0(17, std::vector<double>(1, 0));
double Cd0 = 10;
std::vector<DragEntry> dragData;
// std::vector<double> thrust_time = {/* ...existing code... */};
// std::vector<double> thrust_data = {/* ...existing code... */};
// auto interpolate_thrust = [&](double t) {/* ...existing code... */};

// double gravity = 9.80665;
// double area =  0.01824146924;

// const double T0 = 288.15; // K
// const double P0 = 101325.0;
// double gamma0 = 1.4;
// double R_air = 287.05;
// double mass0 = 49.5;
// double rho0 = 1.225;
// double L = 0.0065;
// double dt = 0.001;
// std::vector<std::vector<double>> x0(17, std::vector<double>(1, 0));
// double Cd0 = 10;
// std::vector<DragEntry> dragData;
// std::vector<double> thrust_time = {0.001,0.011,0.021,0.031,0.041,0.051,0.061,0.071,0.081,0.091,0.101,0.111,0.121,0.131,0.141,0.151,0.161,0.171,0.181,0.191,0.201,0.211,0.221,0.231,0.241,0.251,0.261,0.271,0.281,0.291,0.301,0.311,0.321,0.331,0.341,0.351,0.361,0.371,0.381,0.391,0.401,0.411,0.421,0.431,0.441,0.451,0.461,0.471,0.481,0.491,0.501,0.511,0.521,0.531,0.541,0.551,0.561,0.571,0.581,0.591,0.601,0.611,0.621,0.631,0.641,0.651,0.661,0.671,0.681,0.691,0.701,0.711,0.721,0.731,0.741,0.751,0.761,0.771,0.781,0.791,0.801,0.811,0.821,0.831,0.841,0.851,0.861,0.871,0.881,0.891,0.901,0.911,0.921,0.931,0.941,0.951,0.961,0.971,0.981,0.991,1.001,1.011,1.021,1.031,1.041,1.051,1.061,1.071,1.081,1.091,1.101,1.111,1.121,1.131,1.141,1.151,1.161,1.171,1.181,1.191,1.201,1.211,1.221,1.231,1.241,1.251,1.261,1.271,1.281,1.291,1.301,1.311,1.321,1.331,1.341,1.351,1.361,1.371,1.381,1.391,1.401,1.411,1.421,1.431,1.441,1.451,1.461,1.471,1.481,1.491,1.501,1.511,1.521,1.531,1.541,1.551,1.561,1.571,1.581,1.591,1.601,1.611,1.621,1.631,1.641,1.651,1.661,1.671,1.681,1.691,1.701,1.711,1.721,1.731,1.741,1.751,1.761,1.771,1.781,1.791,1.801,1.811,1.821,1.831,1.841,1.851,1.861,1.871,1.881,1.891,1.901,1.911,1.921,1.931,1.941,1.951,1.961,1.971,1.981,1.991,2.001,2.011,2.021,2.031,2.041,2.051,2.061,2.071,2.081,2.091,2.101,2.111,2.121,2.131,2.141,2.151,2.161,2.171,2.181,2.191,2.201,2.211,2.221,2.231,2.241,2.251,2.261,2.271,2.281,2.291,2.301,2.311,2.321,2.331,2.341,2.351,2.361,2.371,2.381,2.391,2.401,2.411,2.421,2.431,2.441,2.451,2.461,2.471,2.481,2.491,2.501,2.511,2.521,2.531,2.541,2.551,2.561,2.571,2.581,2.591,2.601,2.611,2.621,2.631,2.641,2.651,2.661,2.671,2.681,2.691,2.701,2.711,2.721,2.731,2.741,2.751,2.761,2.771,2.781,2.791,2.801,2.811,2.821,2.831,2.841,2.851,2.861,2.871,2.881,2.891,2.901,2.911,2.921,2.931,2.941,2.951,2.961,2.971,2.981,2.991,3.001,3.011,3.021,3.031,3.041,3.051,3.061,3.071,3.081,3.091,3.101,3.111,3.121,3.131,3.141,3.151,3.161,3.171,3.181,3.191,3.201,3.211,3.221,3.231,3.241,3.251,3.261,3.271,3.281,3.291,3.301,3.311,3.321,3.331,3.341,3.351,3.361,3.371,3.381,3.391,3.401,3.411,3.421,3.431,3.441,3.451,3.461,3.471,3.481,3.491,3.501,3.511,3.521,3.531,3.541,3.551,3.561,3.571,3.581,3.591,3.601,3.611,3.621,3.631,3.641,3.651,3.661,3.671,3.681,3.691,3.701,3.711,3.721,3.731,3.741,3.751,3.761,3.771,3.781,3.791,3.801,3.811,3.821,3.831,3.841,3.851,3.861,3.871,3.881,3.891,3.901,3.911,3.921,3.931,3.941,3.951,3.961,3.971,3.981,3.991,4.001,4.011,4.021,4.031,4.041,4.051,4.061,4.071,4.081,4.091,4.101,4.111,4.121,4.131,4.141,4.151,4.161,4.171,4.181,4.191,4.201,4.211,4.221,4.231,4.241,4.251,4.261,4.271,4.281,4.291,4.301,4.311,4.321,4.331,4.341,4.351,4.361,4.371,4.381,4.391,4.401,4.411,4.421,4.431,4.441,4.451,4.461,4.471,4.481,4.491,4.501,4.511,4.521,4.531,4.541,4.551,4.561,4.571,4.581,4.591,4.601,4.611,4.621,4.631,4.641,4.651,4.661,4.671,4.681,4.691,4.701,4.711,4.721,4.731,4.741,4.751,4.761,4.771,4.781,4.791,4.801,4.811,4.821,4.831,4.841,4.851,4.861,4.871,4.881,4.891,4.901,4.911,4.921,4.931,4.941,4.951,4.961,4.971,4.981,4.991,5.001,5.011,5.021,5.031,5.041,5.051,5.061,5.071,5.081,5.091,5.101,5.111,5.121,5.131,5.141,5.151,5.161,5.171,5.181,5.191,5.201,5.211,5.221,5.231,5.241,5.251,5.261,5.271,5.281,5.291,5.301,5.311,5.321,5.331,5.341,5.351,5.361,5.371,5.381,5.391,5.401,5.411,5.421,5.431,5.441,5.451,5.461,5.471,5.481,5.491,5.501,5.511,5.521,5.531,5.541,5.551,5.561,5.571,5.581,5.591,5.601,5.611,5.621,5.631,5.641,5.651,5.661,5.671,5.681,5.691,5.701,5.711,5.721,5.731,5.741,5.751,5.761,5.771,5.781,5.791,5.801,5.811,5.821,5.831,5.841,5.851,5.861,5.871,5.881,5.891,5.901,5.911,5.921,5.931,5.941,5.951,5.961,5.971,5.981,5.991,6.001,6.011,6.021,6.031,6.041,6.051,6.061,6.071,6.081,6.091,6.101,6.111,6.121,6.131,6.141,6.151,6.161,6.171,6.181,6.191,6.201,6.211,6.221,6.231,6.241,6.251,6.261,6.271,6.281,6.291,6.301,6.311,6.321,6.331,6.341,6.351,6.361,6.371,6.381,6.391,6.401,6.411,6.421,6.431,6.441,6.451,6.461,6.471,6.481,6.491,6.501,6.511,6.521,6.531,6.541,6.551,6.561,6.571,6.581,6.591,6.601,6.611,6.621,6.631,6.641,6.651,6.661,6.671,6.681,6.691,6.701,6.711,6.721,6.731,6.741,6.751,6.761,6.771,6.781,6.791,6.801,6.811,6.821,6.831,6.841,6.851,6.861,6.871,6.881,6.891,6.901,6.911,6.921,6.931,6.941,6.951,6.961,6.971,6.981,6.991,7.001,7.011,7.021,7.031,7.041,7.051,7.061,7.071,7.081,7.091,7.101,7.111,7.121,7.131,7.141,7.151,7.161,7.171,7.181,7.191,7.201,7.211,7.221,7.231,7.241,7.251,7.261,7.271,7.281,7.291,7.301,7.311,7.321,7.331,7.341,7.351,7.361,7.371,7.381,7.391,7.401,7.411,7.421,7.431,7.441,7.451,7.461,7.471,7.481,7.491,7.501,7.511,7.521,7.531,7.541,7.551,7.561,7.571,7.581,7.591,7.601,7.611,7.621,7.631,7.641,7.651,7.661,7.671,7.681,7.691,7.701,7.711,7.721,7.731,7.741,7.751,7.761,7.771,7.781,7.791,7.801,7.811,7.821,7.831,7.841,7.851,7.861,7.871,7.881,7.891,7.901,7.911,7.921,7.931,7.941,7.951,7.961,7.971,7.981,7.991,8.001,8.011,8.021,8.031,8.041,8.051,8.061,8.071,8.081,8.091,8.101,8.111,8.121,8.131,8.141,8.151,8.161,8.171,8.181,8.191,8.201,8.211,8.221,8.231,8.241,8.251,8.261,8.271,8.281,8.291,8.301,8.311,8.321,8.331,8.341,8.351,8.361,8.371,8.381,8.391,8.401,8.411,8.421,8.431,8.441,8.451,8.461,8.471,8.481,8.491,8.501,8.511,8.521,8.531,8.541,8.551,8.561,8.571,8.581,8.591,8.601,8.611,8.621,8.631,8.641,8.651,8.661,8.671,8.681,8.691,8.701,8.711,8.721,8.731,8.741,8.751,8.761,8.771,8.781,8.791,8.801,8.811,8.821,8.831,8.841,8.851,8.861,8.871,8.881,8.891,8.901,8.911,8.921,8.931,8.941,8.951,8.961,8.971,8.981,8.991,9.001,9.011,9.021,9.031,9.041,9.051,9.061,9.071,9.081,9.091,9.101,9.111,9.121,9.131,9.141,9.151,9.161,9.171,9.181,9.191,9.201,9.211,9.221,9.231,9.241,9.251,9.261,9.271,9.281,9.291,9.301,9.311,9.321,9.331,9.341,9.351,9.361,9.371,9.381,9.391,9.401,9.411,9.421,9.431,9.441,9.451,9.461,9.471,9.481,9.491,9.501,9.511,9.521,9.531,9.541,9.551,9.561,9.571,9.581,9.591,9.601,9.611,9.621,9.631,9.641,9.651,9.661,9.671,9.681,9.691,9.701,9.711,9.721,9.731,9.741,9.751,9.761};
// std::vector<double> thrust_data = {31,381,697,987,1250,1491,1711,1911,2093,2258,2408,2544,2668,2779,2880,2971,3053,3126,3193,3252,3305,3352,3394,3431,3464,3493,3518,3541,3560,3577,3591,3603,3613,3622,3629,3634,3638,3641,3643,3644,3644,3644,3643,3641,3639,3636,3633,3630,3626,3622,3617,3613,3608,3603,3598,3593,3587,3582,3576,3571,3565,3559,3553,3547,3541,3536,3530,3524,3518,3512,3506,3500,3494,3488,3482,3476,3470,3464,3458,3452,3446,3440,3435,3429,3423,3417,3412,3406,3400,3395,3389,3383,3378,3372,3367,3361,3356,3350,3345,3339,3334,3329,3323,3318,3313,3308,3302,3297,3292,3287,3282,3277,3272,3267,3262,3257,3252,3247,3242,3237,3232,3227,3223,3218,3213,3208,3203,3199,3194,3189,3185,3180,3176,3171,3166,3162,3157,3153,3148,3144,3140,3135,3131,3126,3122,3117,3113,3108,3104,3100,3095,3091,3086,3082,3078,3073,3069,3065,3061,3056,3052,3048,3044,3040,3035,3031,3027,3023,3019,3015,3011,3007,3003,2999,2995,2991,2987,2983,2979,2975,2971,2967,2963,2959,2955,2952,2948,2944,2940,2936,2933,2929,2925,2921,2918,2914,2910,2907,2903,2899,2896,2892,2889,2885,2882,2878,2875,2871,2868,2864,2861,2857,2854,2850,2846,2842,2838,2834,2830,2826,2823,2819,2815,2811,2807,2803,2799,2795,2791,2787,2783,2779,2776,2772,2768,2764,2760,2757,2753,2749,2745,2742,2738,2734,2731,2727,2724,2720,2716,2713,2709,2706,2702,2699,2695,2692,2689,2685,2682,2678,2675,2672,2668,2665,2662,2659,2655,2652,2649,2646,2643,2639,2636,2633,2630,2627,2624,2621,2618,2614,2611,2608,2605,2602,2599,2596,2593,2590,2587,2584,2581,2579,2576,2573,2570,2567,2564,2561,2558,2556,2553,2550,2547,2544,2542,2539,2536,2533,2530,2528,2525,2522,2520,2517,2514,2511,2509,2506,2503,2501,2498,2495,2493,2490,2488,2485,2482,2480,2477,2475,2472,2470,2467,2464,2462,2459,2457,2454,2452,2449,2447,2444,2442,2440,2437,2435,2432,2430,2428,2425,2423,2420,2418,2416,2413,2411,2409,2406,2404,2402,2399,2397,2395,2393,2390,2388,2386,2384,2381,2379,2377,2375,2372,2370,2368,2366,2364,2362,2359,2357,2355,2353,2351,2349,2347,2344,2342,2340,2338,2336,2334,2332,2330,2328,2326,2324,2321,2319,2317,2315,2313,2311,2309,2307,2305,2303,2301,2299,2297,2295,2293,2291,2289,2287,2285,2283,2282,2280,2278,2276,2274,2272,2270,2268,2266,2264,2262,2261,2259,2257,2255,2253,2251,2249,2248,2246,2244,2242,2240,2238,2237,2235,2233,2231,2229,2228,2226,2224,2222,2221,2219,2217,2215,2214,2212,2210,2208,2207,2205,2203,2202,2200,2198,2196,2195,2193,2191,2190,2188,2186,2185,2183,2181,2180,2178,2176,2175,2173,2172,2170,2168,2167,2165,2163,2162,2160,2159,2157,2155,2154,2152,2151,2149,2148,2146,2144,2143,2141,2140,2138,2137,2135,2134,2132,2131,2129,2127,2126,2124,2123,2121,2120,2118,2117,2115,2114,2112,2111,2109,2108,2107,2105,2104,2102,2101,2099,2098,2096,2095,2093,2092,2090,2089,2087,2086,2085,2083,2082,2080,2079,2077,2076,2075,2073,2072,2070,2069,2068,2066,2065,2063,2062,2061,2059,2058,2057,2055,2054,2052,2051,2050,2048,2047,2046,2044,2043,2042,2040,2039,2038,2036,2035,2034,2032,2031,2030,2028,2027,2026,2024,2023,2022,2021,2019,2018,2017,2015,2014,2013,2012,2010,2009,2008,2007,2005,2004,2003,2001,2000,1999,1998,1997,1995,1994,1993,1992,1990,1989,1988,1987,1985,1984,1983,1982,1981,1979,1978,1977,1976,1975,1973,1972,1971,1970,1969,1967,1966,1965,1964,1963,1962,1960,1959,1958,1957,1956,1955,1953,1952,1951,1950,1949,1948,1947,1945,1944,1943,1942,1941,1940,1939,1938,1936,1935,1934,1933,1932,1931,1930,1929,1927,1926,1925,1924,1923,1922,1921,1920,1919,1918,1917,1915,1914,1913,1912,1911,1910,1909,1908,1907,1906,1905,1904,1903,1902,1901,1900,1898,1897,1896,1895,1894,1893,1892,1891,1890,1889,1888,1887,1886,1885,1884,1883,1882,1881,1880,1879,1878,1877,1876,1875,1874,1873,1872,1871,1870,1869,1868,1867,1866,1865,1864,1863,1862,1861,1860,1859,1858,1857,1856,1855,1854,1853,1852,1851,1850,1849,1848,1847,1846,1845,1844,1843,1842,1770,1699,1634,1573,1517,1465,1416,1369,1326,1285,1246,1210,1175,1143,1112,1083,1055,1029,1004,980,958,936,916,896,878,860,843,827,812,797,783,770,757,744,732,721,710,699,689,679,670,661,652,643,635,627,619,612,605,598,591,584,578,571,565,559,553,548,542,537,531,526,521,516,511,507,502,497,493,488,484,480,476,471,467,463,459,455,451,447,444,440,436,432,429,425,421,418,414,411,407,404,400,397,394,390,387,384,381,377,374,371,368,365,362,359,356,353,350,347,344,341,338,336,333,330,327,325,322,319,316,314,311,309,306,304,301,299,296,294,291,289,286,284,282,279,277,275,272,270,268,265,263,261,259,257,255,252,250,248,246,244,242,240,238,236,234,232,230,228,226,224,222,220,218,217,215,213,211,209,207,206,204,202,200,199,197,195,193,192,190,188,187,185,184,182,180,179,177,176,174,173,171,170,168,167,165,164,162,161,159,158,156,155,154,152,151,149,148,147,145,144,143,141,140,139,138,136,135,134,133,131,130,129,128,126,125,124,123,122,121,119,118,117,116,115,114,113,112,110,109,108,107,106,105,104,103,102,101,100,99,98,97,97,96,95,94,93,92,91,90,89,88,88,87,86,85,84,83,83,82,81,80,79,79,78,77,76,76,75,74,73,73,72,71,70,70,69,68,68,67,66,65,65,64,63,63,62,61,61,60,59,59,58,58,57,56,56,55,54,54,53,53,52,51,51,50,50,49,48,48,47,47,46,46,45,45,44,43,43,42,42,41,41,40,40,39,39,38,38,37,37,36,36,35,35,34,34,33,33,32,32,31,31,30,30,30,29,29,28,28,27,27,26,26,26,25,25,24,24,23,23,23,22,22,21,21,21,20,20,19,19,19,18,18,17,17,17,16,16,16,15,15,15,14,14,13,13,13,12,12,12,11,11,11,10,10,10,9,9,9,8,8,8,7,7,7,6,6,6,5,5,5,4,4,4,4,3,3,3,2,2,2,2,1};

// Rotation Matix functions
vector<double> euler2quat(double phi, double theta, double psi){
    double q0 = cos(psi/2)*cos(theta/2)*cos(phi/2)+sin(psi/2)*sin(theta/2)*sin(phi/2);
    double q1 = cos(psi/2)*cos(theta/2)*sin(phi/2)-sin(psi/2)*sin(theta/2)*cos(phi/2);
    double q2 = cos(psi/2)*sin(theta/2)*cos(phi/2)+sin(psi/2)*cos(theta/2)*sin(phi/2);
    double q3 = sin(psi/2)*cos(theta/2)*cos(phi/2)-cos(psi/2)*sin(theta/2)*sin(phi/2);

    vector<double> q = {q0,q1,q2,q3};
    return q;
};

vector<vector<double>> quat2DCM(double q0, double q1, double q2, double q3){
    vector<vector<double>> R = {{2*pow(q0,2)+2*pow(q1,2)-1, 2*q1*q2+2*q0*q3, 2*q1*q3-2*q0*q2},
                                {2*q1*q2-2*q0*q3, 2*pow(q0,2)+2*pow(q2,2)-1, 2*q2*q3+2*q0*q1},
                                {2*q1*q3+2*q0*q2, 2*q2*q3-2*q0*q1, 2*pow(q0,2)+2*pow(q3,2)-1}};
    return R;               
};

vector<double> rotateQuaternionRate(vector<double> q, vector<vector<double>> omega){
    vector<vector<double>> M1 = {{-q[1], -q[2], -q[3]},
                                 {q[0], -q[3], q[2]},
                                 {q[3], q[0], -q[1]},
                                 {-q[2], q[1], q[0]}};
    vector<vector<double>> result = mat_mul(matrixTimesScaler(0.5, M1), omega);

    vector<double> output = {result[0][0], result[1][0], result[2][0], result[3][0]};
    return output;
}

// Parse CSV file and return drag table
std::vector<DragEntry> parseDragCSV(const std::string& filename) {
    std::vector<DragEntry> table;
    std::ifstream file(filename);
    std::string line;
    // Skip header
    std::getline(file, line);
    while (std::getline(file, line)) {
        std::stringstream ss(line);
        std::string cell;
        std::vector<std::string> cells;
        while (std::getline(ss, cell, ',')) {
            cells.push_back(cell);
        }
        if (cells.size() >= 13) {
            try {
                double mach = std::stod(cells[0]);
                double cd = std::stod(cells[2]);
                double cnalpha = std::stod(cells[12]);
                table.push_back({mach, cd, cnalpha});
                if (mach > 3) break;
            } catch (...) {
                // skip invalid rows
            }
        }
    }
    return table;
}

// Linear interpolation for drag lookup
std::pair<double, double> lookupDrag(double mach, const std::vector<DragEntry>& table) {
    if (table.empty()) {
        return {0, 0};
    }
    // If mach is out of bounds, clamp to ends
    if (mach <= table.front().mach) {
        return {table.front().cd, table.front().cnalpha};
    }
    if (mach >= table.back().mach) {
        return {table.back().cd, table.back().cnalpha};
    }
    // Find interval
    for (size_t i = 1; i < table.size(); ++i) {
        if (mach < table[i].mach) {
            double m0 = table[i-1].mach;
            double m1 = table[i].mach;
            double cd0 = table[i-1].cd;
            double cd1 = table[i].cd;
            double cn0 = table[i-1].cnalpha;
            double cn1 = table[i].cnalpha;
            double t = (mach - m0) / (m1 - m0);
            double cd = cd0 + t * (cd1 - cd0);
            double cnalpha = cn0 + t * (cn1 - cn0);
            return {cd, cnalpha};
        }
    }
    // fallback
    return {table.back().cd, table.back().cnalpha};
}


// auto interpolate_thrust = [&](double t) {
//     if (t <= thrust_time.front()) return thrust_data.front();
//     if (t >= thrust_time.back()) return thrust_data.back();
//     for (size_t i = 1; i < thrust_time.size(); ++i) {
//         if (t < thrust_time[i]) {
//             double t0 = thrust_time[i-1];
//             double t1 = thrust_time[i];
//             double f0 = thrust_data[i-1];
//             double f1 = thrust_data[i];
//             return f0 + (f1-f0)*(t-t0)/(t1-t0);
//         }
//     }
//     return thrust_data.back();
// };

double calculateSoS(double gamma, double R, double T){
    double SoS = sqrt(gamma*R*T);
    return SoS;
}

double calculateMachNumber(double V, double SoS){
    double M = V/SoS;
    return M;
}

vector<vector<double>> calculateH(uint sensor_id, vector<vector<double>> states){
    /*
    sensor_id - Sensor ID to determine which jacobian to use
    states - to calculate jacobian
    H is output


    Sensor IDs:
    - accelerometer/gyro - 0
    - high G accelerometer - 1
    - pressure/temperature - 2
    

    Measurement vector: [a_x, a_y, a_z, p, q, r, P, T]^T
    */

    

    double P_u = states[2][0];

    vector<vector<double>> a_w({{states[6][0]},{states[7][0]},{states[8][0]+gravity}});

    // double a_x = states[6][0];
    // double a_y = states[7][0];
    // double a_z = states[8][0];

    double q0 = states[9][0];
    double q1 = states[10][0];
    double q2 = states[11][0];
    double q3 = states[12][0];

    double q0_dot = states[13][0];
    double q1_dot = states[14][0];
    double q2_dot = states[15][0];
    double q3_dot = states[16][0];


    vector<vector<double>> a_b = mat_mul(quat2DCM(q0,q1,q2,q3),a_w);
    vector<vector<double>> R = quat2DCM(q0,q1,q2,q3);

    vector<vector<double>> H;

    switch (sensor_id){
        case 3:
        H = vector<vector<double>>(6, vector<double>(states.size(), 0));
        for (int i = 0; i<3; i++){
            for (int j = 0; j<3; j++){
                H[i][j+6] = R[i][j];
            }
        }
        // H[0][6] = R[0][0];
        // H[0][7]= H[1][7] = H[2][8] = 1;


        // H[0][9] = 2*q2*gravity;
        // H[0][10] = -2*q3*gravity;
        // H[0][11] = 2*q0*gravity;
        // H[0][12] = -2*q1*gravity;

        // H[1][9] = -2*q1*gravity;
        // H[1][10] = -2*q0*gravity;
        // H[1][11] = -2*q3*gravity;
        // H[1][12] = -2*q2*gravity;

        // H[2][9] = 2*q0*gravity;
        // H[2][10] = -2*q1*gravity;
        // H[2][11] = -2*q2*gravity;
        // H[2][12] = 2*q3*gravity;


        // Jacobian for p
        H[3][9] = 2*q1_dot;
        H[3][10] = -2*q0_dot;
        H[3][11] = -2*q3_dot;
        H[3][12] = 2*q2_dot;
        H[3][13] = -2*q1;
        H[3][14] = 2*q0;
        H[3][15] = 2*q3;
        H[3][16] = -2*q2;

        // Jacobian for q
        H[4][9] = 2*q2_dot;
        H[4][10] = 2*q3_dot;
        H[4][11] = -2*q0_dot;
        H[4][12] = -2*q1_dot;
        H[4][13] = -2*q2;
        H[4][14] = -2*q3;
        H[4][15] = 2*q0;
        H[4][16] = 2*q1;

        // Jacobian for r
        H[5][9] = 2*q3_dot;
        H[5][10] = -2*q2_dot;
        H[5][11] = 2*q1_dot;
        H[5][12] = -2*q0_dot;
        H[5][13] = -2*q3;
        H[5][14] = 2*q2;
        H[5][15] = -2*q1;
        H[5][16] = 2*q0;
        break;



        case 5:
        H = vector<vector<double>>(3, vector<double>(states.size(), 0));
        for (int i = 0; i<3; i++){
            for (int j = 0; j<3; j++){
                H[i][j+6] = R[i][j];
            }
        }

        // H[0][9] = 2*q2*gravity;
        // H[0][10] = -2*q3*gravity;
        // H[0][11] = 2*q0*gravity;
        // H[0][12] = -2*q1*gravity;

        // H[1][9] = -2*q1*gravity;
        // H[1][10] = -2*q0*gravity;
        // H[1][11] = -2*q3*gravity;
        // H[1][12] = -2*q2*gravity;

        // H[2][9] = 2*q0*gravity;
        // H[2][10] = -2*q1*gravity;
        // H[2][11] = -2*q2*gravity;
        // H[2][12] = 2*q3*gravity;
        break;

        case 2:
        H = vector<vector<double>>(2, vector<double>(states.size(), 0));
        // Temperature
        H[1][2] = -L;
        
        // Pressure
        H[0][2] = P0*(-gravity/(R_air*T0))*pow((1-(L*P_u/T0)),(gravity/(R_air*L)-1));
        break;


    }
    return H;

}

vector<vector<double>> calculateHx(uint sensor_id, vector<vector<double>> states){
    /*

    Calculate the expected sensor values to use for the resudual


    Sensor IDs:
    - accelerometer/gyro - 0
    - high_G accelerometer - 1
    - pressure/temperature - 2

    */

    vector<vector<double>> Hx(8, vector<double>(1, 0));

    double P_u = states[2][0];

    vector<vector<double>> a_w({{states[6][0]},{states[7][0]},{states[8][0]+gravity}});

    // double a_x = states[6][0];
    // double a_y = states[7][0];
    // double a_z = states[8][0];

    double q0 = states[9][0];
    double q1 = states[10][0];
    double q2 = states[11][0];
    double q3 = states[12][0];

    double q0_dot = states[13][0];
    double q1_dot = states[14][0];
    double q2_dot = states[15][0];
    double q3_dot = states[16][0];


    vector<vector<double>> a_b = mat_mul(quat2DCM(q0,q1,q2,q3),a_w);

    switch (sensor_id){
        case 3:
        Hx = vector<vector<double>>(6, vector<double>(1, 0));
        Hx[0][0] = a_b[0][0];
        Hx[1][0] = a_b[1][0];
        Hx[2][0] = a_b[2][0];

        Hx[3][0] = 2*(-q0_dot*q1+q1_dot*q0+q2_dot*q3-q3_dot*q2);
        Hx[4][0] = 2*(-q0_dot*q2-q1_dot*q3+q2_dot*q0+q3_dot*q1);
        Hx[5][0] = 2*(-q0_dot*q3+q1_dot*q2-q2_dot*q1+q3_dot*q0);
        break;

        case 5:
        Hx = vector<vector<double>>(3, vector<double>(1, 0));
        Hx[0][0] = a_b[0][0];
        Hx[1][0] = a_b[1][0];
        Hx[2][0] = a_b[2][0];
        break;


        case 2:
        Hx = vector<vector<double>>(2, vector<double>(1, 0));
        Hx[0][0] = P0*pow(((T0-L*P_u)/T0),(gravity/(R_air*L)));
        Hx[1][0] = T0-L*P_u;
        break;
    }
    return Hx;
}

vector<vector<double>> calculateR(const uint sensor_id_){
    vector<vector<double>> R;
    switch (sensor_id_){
        case 3:
        R = vector<vector<double>>(6, vector<double>(6, 0));
        R[0][0] = R[1][1] = R[2][2] = 0.5;
        R[3][3] = R[4][4] = R[5][5] = 0.1;
        break;

        case 5:
        R = vector<vector<double>>(3, vector<double>(3, 0));
        R[0][0] = R[1][1] = R[2][2] = 0.3;
        break;


        case 2:
        R = vector<vector<double>>(2, vector<double>(2, 0));
        R[0][0] = 3;
        R[1][1] = 1;
        break;
    }
    return R;
}


// RK4 for stepping in Update Step
vector<vector<double>> rk4_step_mat(const vector<vector<double>>& y, double dt, const std::function<vector<vector<double>>(const vector<vector<double>>&)> &dydt) {
    vector<vector<double>> k1 = dydt(y);
    vector<vector<double>> y2 = mat_add(y, matrixTimesScaler(dt/2.0, k1));
    vector<vector<double>> k2 = dydt(y2);
    vector<vector<double>> y3 = mat_add(y, matrixTimesScaler(dt/2.0, k2));
    vector<vector<double>> k3 = dydt(y3);
    vector<vector<double>> y4 = mat_add(y, matrixTimesScaler(dt, k3));
    vector<vector<double>> k4 = dydt(y4);
    vector<vector<double>> result = y;
    for (size_t i = 0; i < y.size(); ++i) {
        for (size_t j = 0; j < y[0].size(); ++j) {
            result[i][j] += dt/6.0 * (k1[i][j] + 2*k2[i][j] + 2*k3[i][j] + k4[i][j]);
        }
    }
    return result;
}

vector<double> rk4_step_vec(const vector<double>& y, double dt, const std::function<vector<double>(const vector<double>&)>& dydt) {
    vector<double> k1 = dydt(y);
    vector<double> y2 = vector_add(y, vectorTimesScaler(dt/2.0, k1));
    vector<double> k2 = dydt(y2);
    vector<double> y3 = vector_add(y, vectorTimesScaler(dt/2.0, k2));
    vector<double> k3 = dydt(y3);
    vector<double> y4 = vector_add(y, vectorTimesScaler(dt, k3));
    vector<double> k4 = dydt(y4);
    vector<double> result(y.size());
    for (size_t i = 0; i < y.size(); ++i) {
        result[i] = y[i] + dt/6.0 * (k1[i] + 2*k2[i] + 2*k3[i] + k4[i]);
    }
    return result;
}

// Force Calculation for Update
vector<vector<double>> calculateBodyForces(vector<double> quat, double drag, double thrust, double mass, double gravity_){

    // Calculate the forces acting on the aircraft in the body frame
    vector<vector<double>> R = quat2DCM(quat[0],quat[1],quat[2],quat[3]);
    vector<vector<double>> g_w = {{0},{0},{-gravity_*mass}};

    vector<vector<double>> d = mat_mul(R,{{0},{0},{-drag}});
    vector<vector<double>> t = mat_mul(R,{{0},{0},{thrust}});

    vector<vector<double>> F_w = mat_add(g_w,mat_add(d,t));
    return F_w;
}

// Calculate Acceleration for update
vector<vector<double>> calculateAcceleration(vector<vector<double>> F_b, double m, vector<vector<double>> omega_b, vector<vector<double>> V_b){
    
    // vector<vector<double>> a_rot = {{omega_b[2][0]*V_b[1][0]-omega_b[1][0]*V_b[2][0]},
    //                                 {omega_b[0][0]*V_b[2][0]-omega_b[2][0]*V_b[0][0]},
    //                                 {omega_b[1][0]*V_b[0][0]-omega_b[0][0]*V_b[1][0]}};

    vector<vector<double>> a_b = matrixTimesScaler(1/m, F_b);

    return a_b;
}

// Calculate Rotational Acceleration for Update
vector<vector<double>> calculateRotationalAcceleration(vector<vector<double>> I, vector<vector<double>> omega_b, vector<vector<double>> M_b){
    vector<vector<double>> rot_accel = mat_mul(inverseMatrix(I),mat_add(crossProduct(negative(omega_b),mat_mul(I,omega_b)),M_b));
    return rot_accel;
}



int main(){

    // Import Drag Information and save to look up
    vector<DragEntry> dragData = parseDragCSV("../CD Test.CSV");

    // Import Thrust Information and save to look up
    vector<double> thrust_time = {0.001,0.011,0.021,0.031,0.041,0.051,0.061,0.071,0.081,0.091,0.101,0.111,0.121,0.131,0.141,0.151,0.161,0.171,0.181,0.191,0.201,0.211,0.221,0.231,0.241,0.251,0.261,0.271,0.281,0.291,0.301,0.311,0.321,0.331,0.341,0.351,0.361,0.371,0.381,0.391,0.401,0.411,0.421,0.431,0.441,0.451,0.461,0.471,0.481,0.491,0.501,0.511,0.521,0.531,0.541,0.551,0.561,0.571,0.581,0.591,0.601,0.611,0.621,0.631,0.641,0.651,0.661,0.671,0.681,0.691,0.701,0.711,0.721,0.731,0.741,0.751,0.761,0.771,0.781,0.791,0.801,0.811,0.821,0.831,0.841,0.851,0.861,0.871,0.881,0.891,0.901,0.911,0.921,0.931,0.941,0.951,0.961,0.971,0.981,0.991,1.001,1.011,1.021,1.031,1.041,1.051,1.061,1.071,1.081,1.091,1.101,1.111,1.121,1.131,1.141,1.151,1.161,1.171,1.181,1.191,1.201,1.211,1.221,1.231,1.241,1.251,1.261,1.271,1.281,1.291,1.301,1.311,1.321,1.331,1.341,1.351,1.361,1.371,1.381,1.391,1.401,1.411,1.421,1.431,1.441,1.451,1.461,1.471,1.481,1.491,1.501,1.511,1.521,1.531,1.541,1.551,1.561,1.571,1.581,1.591,1.601,1.611,1.621,1.631,1.641,1.651,1.661,1.671,1.681,1.691,1.701,1.711,1.721,1.731,1.741,1.751,1.761,1.771,1.781,1.791,1.801,1.811,1.821,1.831,1.841,1.851,1.861,1.871,1.881,1.891,1.901,1.911,1.921,1.931,1.941,1.951,1.961,1.971,1.981,1.991,2.001,2.011,2.021,2.031,2.041,2.051,2.061,2.071,2.081,2.091,2.101,2.111,2.121,2.131,2.141,2.151,2.161,2.171,2.181,2.191,2.201,2.211,2.221,2.231,2.241,2.251,2.261,2.271,2.281,2.291,2.301,2.311,2.321,2.331,2.341,2.351,2.361,2.371,2.381,2.391,2.401,2.411,2.421,2.431,2.441,2.451,2.461,2.471,2.481,2.491,2.501,2.511,2.521,2.531,2.541,2.551,2.561,2.571,2.581,2.591,2.601,2.611,2.621,2.631,2.641,2.651,2.661,2.671,2.681,2.691,2.701,2.711,2.721,2.731,2.741,2.751,2.761,2.771,2.781,2.791,2.801,2.811,2.821,2.831,2.841,2.851,2.861,2.871,2.881,2.891,2.901,2.911,2.921,2.931,2.941,2.951,2.961,2.971,2.981,2.991,3.001,3.011,3.021,3.031,3.041,3.051,3.061,3.071,3.081,3.091,3.101,3.111,3.121,3.131,3.141,3.151,3.161,3.171,3.181,3.191,3.201,3.211,3.221,3.231,3.241,3.251,3.261,3.271,3.281,3.291,3.301,3.311,3.321,3.331,3.341,3.351,3.361,3.371,3.381,3.391,3.401,3.411,3.421,3.431,3.441,3.451,3.461,3.471,3.481,3.491,3.501,3.511,3.521,3.531,3.541,3.551,3.561,3.571,3.581,3.591,3.601,3.611,3.621,3.631,3.641,3.651,3.661,3.671,3.681,3.691,3.701,3.711,3.721,3.731,3.741,3.751,3.761,3.771,3.781,3.791,3.801,3.811,3.821,3.831,3.841,3.851,3.861,3.871,3.881,3.891,3.901,3.911,3.921,3.931,3.941,3.951,3.961,3.971,3.981,3.991,4.001,4.011,4.021,4.031,4.041,4.051,4.061,4.071,4.081,4.091,4.101,4.111,4.121,4.131,4.141,4.151,4.161,4.171,4.181,4.191,4.201,4.211,4.221,4.231,4.241,4.251,4.261,4.271,4.281,4.291,4.301,4.311,4.321,4.331,4.341,4.351,4.361,4.371,4.381,4.391,4.401,4.411,4.421,4.431,4.441,4.451,4.461,4.471,4.481,4.491,4.501,4.511,4.521,4.531,4.541,4.551,4.561,4.571,4.581,4.591,4.601,4.611,4.621,4.631,4.641,4.651,4.661,4.671,4.681,4.691,4.701,4.711,4.721,4.731,4.741,4.751,4.761,4.771,4.781,4.791,4.801,4.811,4.821,4.831,4.841,4.851,4.861,4.871,4.881,4.891,4.901,4.911,4.921,4.931,4.941,4.951,4.961,4.971,4.981,4.991,5.001,5.011,5.021,5.031,5.041,5.051,5.061,5.071,5.081,5.091,5.101,5.111,5.121,5.131,5.141,5.151,5.161,5.171,5.181,5.191,5.201,5.211,5.221,5.231,5.241,5.251,5.261,5.271,5.281,5.291,5.301,5.311,5.321,5.331,5.341,5.351,5.361,5.371,5.381,5.391,5.401,5.411,5.421,5.431,5.441,5.451,5.461,5.471,5.481,5.491,5.501,5.511,5.521,5.531,5.541,5.551,5.561,5.571,5.581,5.591,5.601,5.611,5.621,5.631,5.641,5.651,5.661,5.671,5.681,5.691,5.701,5.711,5.721,5.731,5.741,5.751,5.761,5.771,5.781,5.791,5.801,5.811,5.821,5.831,5.841,5.851,5.861,5.871,5.881,5.891,5.901,5.911,5.921,5.931,5.941,5.951,5.961,5.971,5.981,5.991,6.001,6.011,6.021,6.031,6.041,6.051,6.061,6.071,6.081,6.091,6.101,6.111,6.121,6.131,6.141,6.151,6.161,6.171,6.181,6.191,6.201,6.211,6.221,6.231,6.241,6.251,6.261,6.271,6.281,6.291,6.301,6.311,6.321,6.331,6.341,6.351,6.361,6.371,6.381,6.391,6.401,6.411,6.421,6.431,6.441,6.451,6.461,6.471,6.481,6.491,6.501,6.511,6.521,6.531,6.541,6.551,6.561,6.571,6.581,6.591,6.601,6.611,6.621,6.631,6.641,6.651,6.661,6.671,6.681,6.691,6.701,6.711,6.721,6.731,6.741,6.751,6.761,6.771,6.781,6.791,6.801,6.811,6.821,6.831,6.841,6.851,6.861,6.871,6.881,6.891,6.901,6.911,6.921,6.931,6.941,6.951,6.961,6.971,6.981,6.991,7.001,7.011,7.021,7.031,7.041,7.051,7.061,7.071,7.081,7.091,7.101,7.111,7.121,7.131,7.141,7.151,7.161,7.171,7.181,7.191,7.201,7.211,7.221,7.231,7.241,7.251,7.261,7.271,7.281,7.291,7.301,7.311,7.321,7.331,7.341,7.351,7.361,7.371,7.381,7.391,7.401,7.411,7.421,7.431,7.441,7.451,7.461,7.471,7.481,7.491,7.501,7.511,7.521,7.531,7.541,7.551,7.561,7.571,7.581,7.591,7.601,7.611,7.621,7.631,7.641,7.651,7.661,7.671,7.681,7.691,7.701,7.711,7.721,7.731,7.741,7.751,7.761,7.771,7.781,7.791,7.801,7.811,7.821,7.831,7.841,7.851,7.861,7.871,7.881,7.891,7.901,7.911,7.921,7.931,7.941,7.951,7.961,7.971,7.981,7.991,8.001,8.011,8.021,8.031,8.041,8.051,8.061,8.071,8.081,8.091,8.101,8.111,8.121,8.131,8.141,8.151,8.161,8.171,8.181,8.191,8.201,8.211,8.221,8.231,8.241,8.251,8.261,8.271,8.281,8.291,8.301,8.311,8.321,8.331,8.341,8.351,8.361,8.371,8.381,8.391,8.401,8.411,8.421,8.431,8.441,8.451,8.461,8.471,8.481,8.491,8.501,8.511,8.521,8.531,8.541,8.551,8.561,8.571,8.581,8.591,8.601,8.611,8.621,8.631,8.641,8.651,8.661,8.671,8.681,8.691,8.701,8.711,8.721,8.731,8.741,8.751,8.761,8.771,8.781,8.791,8.801,8.811,8.821,8.831,8.841,8.851,8.861,8.871,8.881,8.891,8.901,8.911,8.921,8.931,8.941,8.951,8.961,8.971,8.981,8.991,9.001,9.011,9.021,9.031,9.041,9.051,9.061,9.071,9.081,9.091,9.101,9.111,9.121,9.131,9.141,9.151,9.161,9.171,9.181,9.191,9.201,9.211,9.221,9.231,9.241,9.251,9.261,9.271,9.281,9.291,9.301,9.311,9.321,9.331,9.341,9.351,9.361,9.371,9.381,9.391,9.401,9.411,9.421,9.431,9.441,9.451,9.461,9.471,9.481,9.491,9.501,9.511,9.521,9.531,9.541,9.551,9.561,9.571,9.581,9.591,9.601,9.611,9.621,9.631,9.641,9.651,9.661,9.671,9.681,9.691,9.701,9.711,9.721,9.731,9.741,9.751,9.761};
    vector<double> thrust_data = {31,381,697,987,1250,1491,1711,1911,2093,2258,2408,2544,2668,2779,2880,2971,3053,3126,3193,3252,3305,3352,3394,3431,3464,3493,3518,3541,3560,3577,3591,3603,3613,3622,3629,3634,3638,3641,3643,3644,3644,3644,3643,3641,3639,3636,3633,3630,3626,3622,3617,3613,3608,3603,3598,3593,3587,3582,3576,3571,3565,3559,3553,3547,3541,3536,3530,3524,3518,3512,3506,3500,3494,3488,3482,3476,3470,3464,3458,3452,3446,3440,3435,3429,3423,3417,3412,3406,3400,3395,3389,3383,3378,3372,3367,3361,3356,3350,3345,3339,3334,3329,3323,3318,3313,3308,3302,3297,3292,3287,3282,3277,3272,3267,3262,3257,3252,3247,3242,3237,3232,3227,3223,3218,3213,3208,3203,3199,3194,3189,3185,3180,3176,3171,3166,3162,3157,3153,3148,3144,3140,3135,3131,3126,3122,3117,3113,3108,3104,3100,3095,3091,3086,3082,3078,3073,3069,3065,3061,3056,3052,3048,3044,3040,3035,3031,3027,3023,3019,3015,3011,3007,3003,2999,2995,2991,2987,2983,2979,2975,2971,2967,2963,2959,2955,2952,2948,2944,2940,2936,2933,2929,2925,2921,2918,2914,2910,2907,2903,2899,2896,2892,2889,2885,2882,2878,2875,2871,2868,2864,2861,2857,2854,2850,2846,2842,2838,2834,2830,2826,2823,2819,2815,2811,2807,2803,2799,2795,2791,2787,2783,2779,2776,2772,2768,2764,2760,2757,2753,2749,2745,2742,2738,2734,2731,2727,2724,2720,2716,2713,2709,2706,2702,2699,2695,2692,2689,2685,2682,2678,2675,2672,2668,2665,2662,2659,2655,2652,2649,2646,2643,2639,2636,2633,2630,2627,2624,2621,2618,2614,2611,2608,2605,2602,2599,2596,2593,2590,2587,2584,2581,2579,2576,2573,2570,2567,2564,2561,2558,2556,2553,2550,2547,2544,2542,2539,2536,2533,2530,2528,2525,2522,2520,2517,2514,2511,2509,2506,2503,2501,2498,2495,2493,2490,2488,2485,2482,2480,2477,2475,2472,2470,2467,2464,2462,2459,2457,2454,2452,2449,2447,2444,2442,2440,2437,2435,2432,2430,2428,2425,2423,2420,2418,2416,2413,2411,2409,2406,2404,2402,2399,2397,2395,2393,2390,2388,2386,2384,2381,2379,2377,2375,2372,2370,2368,2366,2364,2362,2359,2357,2355,2353,2351,2349,2347,2344,2342,2340,2338,2336,2334,2332,2330,2328,2326,2324,2321,2319,2317,2315,2313,2311,2309,2307,2305,2303,2301,2299,2297,2295,2293,2291,2289,2287,2285,2283,2282,2280,2278,2276,2274,2272,2270,2268,2266,2264,2262,2261,2259,2257,2255,2253,2251,2249,2248,2246,2244,2242,2240,2238,2237,2235,2233,2231,2229,2228,2226,2224,2222,2221,2219,2217,2215,2214,2212,2210,2208,2207,2205,2203,2202,2200,2198,2196,2195,2193,2191,2190,2188,2186,2185,2183,2181,2180,2178,2176,2175,2173,2172,2170,2168,2167,2165,2163,2162,2160,2159,2157,2155,2154,2152,2151,2149,2148,2146,2144,2143,2141,2140,2138,2137,2135,2134,2132,2131,2129,2127,2126,2124,2123,2121,2120,2118,2117,2115,2114,2112,2111,2109,2108,2107,2105,2104,2102,2101,2099,2098,2096,2095,2093,2092,2090,2089,2087,2086,2085,2083,2082,2080,2079,2077,2076,2075,2073,2072,2070,2069,2068,2066,2065,2063,2062,2061,2059,2058,2057,2055,2054,2052,2051,2050,2048,2047,2046,2044,2043,2042,2040,2039,2038,2036,2035,2034,2032,2031,2030,2028,2027,2026,2024,2023,2022,2021,2019,2018,2017,2015,2014,2013,2012,2010,2009,2008,2007,2005,2004,2003,2001,2000,1999,1998,1997,1995,1994,1993,1992,1990,1989,1988,1987,1985,1984,1983,1982,1981,1979,1978,1977,1976,1975,1973,1972,1971,1970,1969,1967,1966,1965,1964,1963,1962,1960,1959,1958,1957,1956,1955,1953,1952,1951,1950,1949,1948,1947,1945,1944,1943,1942,1941,1940,1939,1938,1936,1935,1934,1933,1932,1931,1930,1929,1927,1926,1925,1924,1923,1922,1921,1920,1919,1918,1917,1915,1914,1913,1912,1911,1910,1909,1908,1907,1906,1905,1904,1903,1902,1901,1900,1898,1897,1896,1895,1894,1893,1892,1891,1890,1889,1888,1887,1886,1885,1884,1883,1882,1881,1880,1879,1878,1877,1876,1875,1874,1873,1872,1871,1870,1869,1868,1867,1866,1865,1864,1863,1862,1861,1860,1859,1858,1857,1856,1855,1854,1853,1852,1851,1850,1849,1848,1847,1846,1845,1844,1843,1842,1770,1699,1634,1573,1517,1465,1416,1369,1326,1285,1246,1210,1175,1143,1112,1083,1055,1029,1004,980,958,936,916,896,878,860,843,827,812,797,783,770,757,744,732,721,710,699,689,679,670,661,652,643,635,627,619,612,605,598,591,584,578,571,565,559,553,548,542,537,531,526,521,516,511,507,502,497,493,488,484,480,476,471,467,463,459,455,451,447,444,440,436,432,429,425,421,418,414,411,407,404,400,397,394,390,387,384,381,377,374,371,368,365,362,359,356,353,350,347,344,341,338,336,333,330,327,325,322,319,316,314,311,309,306,304,301,299,296,294,291,289,286,284,282,279,277,275,272,270,268,265,263,261,259,257,255,252,250,248,246,244,242,240,238,236,234,232,230,228,226,224,222,220,218,217,215,213,211,209,207,206,204,202,200,199,197,195,193,192,190,188,187,185,184,182,180,179,177,176,174,173,171,170,168,167,165,164,162,161,159,158,156,155,154,152,151,149,148,147,145,144,143,141,140,139,138,136,135,134,133,131,130,129,128,126,125,124,123,122,121,119,118,117,116,115,114,113,112,110,109,108,107,106,105,104,103,102,101,100,99,98,97,97,96,95,94,93,92,91,90,89,88,88,87,86,85,84,83,83,82,81,80,79,79,78,77,76,76,75,74,73,73,72,71,70,70,69,68,68,67,66,65,65,64,63,63,62,61,61,60,59,59,58,58,57,56,56,55,54,54,53,53,52,51,51,50,50,49,48,48,47,47,46,46,45,45,44,43,43,42,42,41,41,40,40,39,39,38,38,37,37,36,36,35,35,34,34,33,33,32,32,31,31,30,30,30,29,29,28,28,27,27,26,26,26,25,25,24,24,23,23,23,22,22,21,21,21,20,20,19,19,19,18,18,17,17,17,16,16,16,15,15,15,14,14,13,13,13,12,12,12,11,11,11,10,10,10,9,9,9,8,8,8,7,7,7,6,6,6,5,5,5,4,4,4,4,3,3,3,2,2,2,2,1};
    
    auto interpolate_thrust = [&](double t) {
        if (t <= thrust_time.front()) return 0.0;
        if (t >= thrust_time.back()) return 0.0;
        for (size_t i = 1; i < thrust_time.size(); ++i) {
            if (t < thrust_time[i]) {
                double t0 = thrust_time[i-1];
                double t1 = thrust_time[i];
                double f0 = thrust_data[i-1];
                double f1 = thrust_data[i];
                return f0 + (f1-f0)*(t-t0)/(t1-t0);
            }
        }
        return thrust_data.back();
    };


    vector<vector<double>> initial_states = {{0},{0},{0},{0},{0},{0},{0},{0},{0},{1},{0},{0},{0},{0},{0},{0},{0}};

    //Function to calculate Jacobian
    auto Jacobian_F = [&] (const vector<vector<double>> state_, const double CD_, const double thrust_, const double area_, const double rho_, const double mass_, const double g_, const double dt_){
        vector<vector<double>> result(state_.size(), vector<double>(state_.size(),0));

        double Vbx = state_[3][0];
        double Vby = state_[4][0];
        double Vbz = state_[5][0];

        double q0 = state_[9][0];
        double q1 = state_[10][0];
        double q2 = state_[11][0];
        double q3 = state_[12][0];

        
        // add all the ones for integrating
        result[0][0] = 1;
        result[1][1] = 1;
        result[2][2] = 1;
        result[3][3] = 1;
        result[4][4] = 1;
        result[5][5] = 1;
        result[9][9] = 1;
        result[10][10] = 1;
        result[11][11] = 1;
        result[12][12] = 1;
        result[13][13] = 1;
        result[14][14] = 1;
        result[15][15] = 1;
        result[16][16] = 1;

        //Partials for Pe

            //velocity partials
            result[0][3] = dt_;

            // acceleration partial
            result[0][6] = pow(dt_,2)/2;

        // Partials for Pn

            //velocity partials
            result[1][4] = dt_;

            // acceleration partial
            result[1][7] = pow(dt_,2)/2;
            
        //Partials for Pu

            //velocity partials
            result[2][5] = dt_;

            // acceleration partial
            result[2][8] = pow(dt_,2)/2;

        //Partials for Vwx
            result[3][6] = dt_;

        // Partials for Vwy
            result[4][7] = dt_;

        // Partials for Vwz
            result[5][8] = dt_;

        // Partials for abx

            //drag
            result[6][3] = -rho_*area_*CD_*state_[3][0]/mass_;

        // Partials for aby

            //drag
            result[7][4] = -rho_*area_*CD_*state_[4][0]/mass_;


        // Partials for abz

            //drag
            result[8][5] = -rho_*area_*CD_*state_[5][0]/mass_;


        //Partials for q0
            result[9][13] = dt_;

        //Partials for q0
            result[10][14] = dt_;

        //Partials for q0
            result[11][15] = dt_;

        //Partials for q0
            result[12][16] = dt_;


        return result;
    };

    auto calcFx = [&] (vector<vector<double>> states_, const double CD_, const double thrust_, const double area_, const double rho_, const double mass_, const double g_, const double dt_){
        vector<vector<double>> results(states_.size(), vector<double>(1,0));

        double P_e = states_[0][0];
        double P_n = states_[1][0];
        double P_u = states_[2][0];

        double vx = states_[3][0];
        double vy = states_[4][0];
        double vz = states_[5][0];

        double ax = states_[6][0];
        double ay = states_[7][0];
        double az = states_[8][0];

        double q0 = states_[9][0];
        double q1 = states_[10][0];
        double q2 = states_[11][0];
        double q3 = states_[12][0];

        double q0_dot = states_[13][0];
        double q1_dot = states_[14][0];
        double q2_dot = states_[15][0];
        double q3_dot = states_[16][0];
        
        vector<vector<double>> vb({{vx},{vy},{vz}});
        vector<double> q({q0, q1, q2, q3});
        double drag = 0.5*rho_*area_*CD_*pow(magnitude({vb[0][0], vb[1][0],vb[2][0]}),2)*CD_;
        double p= 2*(-q0_dot*q1+q1_dot*q0+q2_dot*q3-q3_dot*q2);
        double q_rate = 2*(-q0_dot*q2-q1_dot*q3+q2_dot*q0+q3_dot*q1); // named q_rate to avoid conflict with quaternions
        double r = 2*(-q0_dot*q3+q1_dot*q2-q2_dot*q1+q3_dot*q0);
        vector<vector<double>> omega_b({{p}, {q_rate}, {r}});

        vector<vector<double>> x_enu({{P_e},{P_n},{P_u}});

        // TODO Update I and M
        vector<vector<double>> I({{1,0,0},{0,1,0},{0,0,1}});
        vector<vector<double>> M_b({{0},{0},{0}});

        vector<vector<double>> a = calculateAcceleration(calculateBodyForces(q, drag, thrust_, mass_, g_), mass_, omega_b, vb);
        cout << "ax: " << a[0][0] << " ay: " << a[1][0] << " az: " << a[2][0] << endl;
        results[6][0] = a[0][0];
        results[7][0] = a[1][0];
        results[8][0] = a[2][0];

        auto vb_dydt = [&](const vector<vector<double>>& vb_) {
            vector<vector<double>> Fb = calculateBodyForces(q, drag, thrust_, mass_,g_);
            return calculateAcceleration(Fb, mass_, omega_b, vb_);
        };
        vb = rk4_step_mat(vb, dt, vb_dydt);
        results[3][0] = vb[0][0];
        results[4][0] = vb[1][0];
        results[5][0] = vb[2][0];
        

        // RK4 for omega_b
        auto omega_dydt = [&](const vector<vector<double>>& omega_) {
            return calculateRotationalAcceleration(I, omega_, M_b);
        };
        omega_b = rk4_step_mat(omega_b, dt, omega_dydt);
        results[13][0] = q0_dot;
        results[14][0] = q1_dot;
        results[15][0] = q2_dot;
        results[16][0] = q3_dot;

        // RK4 for quaternion
        auto quat_dydt = [&](const vector<double>& q_) {
            return rotateQuaternionRate(q_, omega_b);
        };
        q = rk4_step_vec(q, dt, quat_dydt);

        if (magnitude(q) > 1.00000001 || magnitude(q)<(1-0.00000001)) {
            q = vectorTimesScaler(1/magnitude(q), q);
        }
        results[9][0] = q[0];
        results[10][0] = q[1];
        results[11][0] = q[2];
        results[12][0] = q[3];

        // RK4 for position
        auto x_dydt = [&](const vector<vector<double>>& x_) {
            vector<vector<double>> V_w0 = vb;
            vector<vector<double>> adt = matrixTimesScaler(dt, a);
            vector<vector<double>> dxdt = mat_add(vb,adt);
            return dxdt;
        };
        x_enu = rk4_step_mat(x_enu, dt, x_dydt);
        results[0][0] = x_enu[0][0];
        results[1][0] = x_enu[1][0];
        results[2][0] = x_enu[2][0];


        return results;
    };


    // Function to calculate the Q Matrix
    auto Q_Calculation = [&] (const vector<vector<double>> state_, const double dt_){
        vector<vector<double>> result(state_.size(), vector<double>(state_.size(),0));

        // Position Covariance
        result[0][0] = result[1][1] = result[2][2] = pow(dt_,5)/20;

        // Position / Velocity Covariance
        result[0][3] = result[3][0] = pow(dt_,4)/8;
        result[1][4] = result[4][1] = pow(dt_,4)/8;
        result[2][5] = result[5][2] = pow(dt_,4)/8;

        // Position / Acceleration Covariance
        result[0][6] = result[6][0] = pow(dt_,3)/6;
        result[1][7] = result[7][1] = pow(dt_,3)/6;
        result[2][8] = result[8][2] = pow(dt_,3)/6;

        // Velocity Covariance
        result[3][3] = result[4][4] = result[5][5] = pow(dt_,3)/3;

        // Velocity / acceleration covariance
        result[3][6] = result[6][3] = pow(dt_,2)/2;
        result[4][7] = result[7][4] = pow(dt_,2)/2;
        result[5][8] = result[8][5] = pow(dt_,2)/2;

        // Acceleration covariance
        result[6][6] = result[7][7] = result[8][8] = dt_;

        // quaternion covariance
        result[9][9] = result[10][10] = result[11][11] = result[12][12] = pow(dt_,3)/3;

        // quaternion rate covariance
        result[13][13] = result[14][14] = result[15][15] = result[16][16] = dt_;

        // quaternion / quaternion rate covariance
        result[9][13] = result[13][9] = pow(dt_,2)/2;
        result[10][14] = result[14][10] = pow(dt_,2)/2;
        result[11][15] = result[15][11] = pow(dt_,2)/2;
        result[12][16] = result[16][12] = pow(dt_, 2)/2;
        
        return result;
    };

    auto Jacobian_H = [&] (const int sensor_id_, const vector<vector<double>> states_) {
        vector<vector<double>> H = calculateH(sensor_id_, states_);
        return H;
    };

    auto calcHx = [&] (uint sensor_id_, vector<vector<double>> states_){
        vector<vector<double>> Hx = calculateHx(sensor_id_, states_);
        return Hx;
    };

    auto calcR = [&] (const uint sensor_id_){
        vector<vector<double>> R = calculateR(sensor_id_);
        return R;
    };

    vector<vector<double>> x0(17,vector<double>(1,0));
    x0[2][0] = 848;
    x0[9][0] = 1;
    double Cd0 = 10;

    double dt = 0.001;




    vector<vector<double>> F0 = Jacobian_F(x0, Cd0, 0, area, rho0, mass0, gravity, dt);

    // Increase process noise for stability
    vector<vector<double>> Q0 = Q_Calculation(x0, 0.05);
    // for (size_t i = 0; i < Q0.size(); ++i) Q0[i][i] += 0.25;

    printMatrix(F0);

    cout << "\n\n Covariance Q \n";

    printMatrix(Q0);

    vector<vector<double>> P = eye(F0.size());
    // More conservative initial covariance for stability
    for (size_t i = 0; i < P.size(); ++i) P[i][i] = 0.1;
    P[0][0] = P[1][1] = 1;
    P[2][2] = 10; // Initial height uncertainty
    P[3][3] = P[4][4] = P[5][5] = 1; // Initial velocity uncertainty
    P[6][6] = P[7][7] = P[8][8] = 1; // Initial acceleration uncertainty
    P[9][9] = P[10][10] = P[11][11] = P[12][12] = 0.5; // Quaternion
    P[13][13] = P[14][14] = P[15][15] = P[16][16] = 0.5; // Quaternion rate

    vector<vector<double>> B(F0.size(), vector<double>(1, 0));
    B[8][0] = 1/mass0;

    vector<vector<double>> z; //Variable to store sensor readings, initialized with 0s (readings - ax, ay, az, wx, wy, wz, P, T)

    vector<vector<double>> R0(6, vector<double>(6,0));
    // Increase measurement noise for stability
    R0[0][0] = R0[1][1] = R0[2][2] = 0.5; // Accelerometer
    R0[3][3] = R0[4][4] = R0[5][5] = 0.1; // Gyro
    // R0[6][6] = 2; // Barometer
    // R0[7][7] = 2; // Temperature



    ExtendedKalmanFilter EKF;

    EKF.F = F0;
    EKF.Q = Q0;
    EKF.Jf = Jacobian_F;
    EKF.calcFx = calcFx;
    EKF.Q_calc = Q_Calculation;
    EKF.x = x0;
    EKF.P = P;
    EKF.B = B;
    EKF.Jh = Jacobian_H;
    EKF.calcHx = calcHx;
    EKF.calcR = calcR;
    EKF.R = R0;


    
    double t = 0;

    // Open 002.txt for reading
    std::ifstream data_file("../Rocket_Simulation/SimulatedSensors.txt");
    if (!data_file.is_open()) {
        std::cerr << "Failed to open ../002.txt" << std::endl;
        return 1;
    }

    std::string line;
    uint64_t prev_timestamp = 0;
    uint64_t curr_timestamp = 0;
    int curr_sensor_id = 0;
    std::vector<double> curr_readings(8, 0.0); // Data1-Data6
    double thr, cd, rho, cna;
    double SoS, mach;
    int step = 0;
    rho = rho0;

    // Kalman filter starts running at 3006604670
    bool attitude_determined(true);
    double q_mag;
    int update_count(0);
    cout << "Entering loop\n";

    // Rocket thrust starts at 
    while (std::getline(data_file, line)) {
        std::stringstream ss(line);
        std::string field;
        std::vector<std::string> fields;
        while (std::getline(ss, field, '|')) {
            fields.push_back(field);
        }
        if (fields.size() < 2) continue; // skip invalid lines
        curr_timestamp = std::stoull(fields[0]);
        if (std::stoull(fields[0])>0){ // 3006604670 for real data
            cout << fields[0] << endl;
            // cout << fields[1] << endl;
            curr_sensor_id = std::stoi(fields[1]);
            cout << "Fields Size: " << fields.size() << endl << "Last Value in Fields: " << fields.back() << endl;
            for (size_t i = 0; i < 6; ++i) {
                if (fields.size() > 2 + i && !fields[2 + i].empty())
                    curr_readings[i] = std::stod(fields[2 + i]);
                else
                    curr_readings[i] = 0.0;
            }

            // z[0][0] = z[1][0] = z[2][0] = z[3][0] = z[4][0] = z[5][0] = z[6][0] = z[7][0] = 0;
            cout << "Sensor ID: " << curr_sensor_id << endl;

            switch (curr_sensor_id){
                case 2:
                    z = vector<vector<double>>(2, vector<double>(1,0));
                    z[0][0] = curr_readings[0];
                    z[1][0] = curr_readings[1];
                    cout << "Case 2 \n";
                    break;

                case 3:
                    z = vector<vector<double>>(6, vector<double>(1,0));
                    z[0][0] = curr_readings[0];
                    z[1][0] = curr_readings[1];
                    z[2][0] = curr_readings[2];
                    z[3][0] = curr_readings[3];
                    z[4][0] = curr_readings[4];
                    z[5][0] = curr_readings[5];
                    cout << "Case 3 \n";
                    cout << curr_readings[5] << endl;
                    if (!attitude_determined){
                        double theta = asin(-z[0][0]/gravity);
                        double phi = asin(z[1][0]/(cos(theta)*gravity));
                        cout << "Theta: " << theta << " Phi: " << phi << endl;
                        vector<double> quats = euler2quat(phi, theta, 0);
                        EKF.x[9][0] = quats[0];
                        EKF.x[10][0] = quats[1];
                        EKF.x[11][0] = quats[2];
                        EKF.x[12][0] = quats[3];
                        cout << "q0: " << EKF.x[9][0] << " q1: " << EKF.x[10][0] << " q2: " << EKF.x[11][0] << " q3: " << EKF.x[12][0] << endl;
                        attitude_determined = true;
                    }
                    break;

                case 5:
                    z = vector<vector<double>>(3, vector<double>(1,0));
                    z[0][0] = curr_readings[0];
                    z[1][0] = curr_readings[1];
                    z[2][0] = curr_readings[2];
                    if (!attitude_determined){
                        double theta = asin(-z[0][0]/gravity);
                        double phi = asin(z[1][0]/(cos(theta)*gravity));
                        cout << "Theta: " << theta << " Phi: " << phi << endl;
                        vector<double> quats = euler2quat(phi, theta, 0);
                        EKF.x[9][0] = quats[0];
                        EKF.x[10][0] = quats[1];
                        EKF.x[11][0] = quats[2];
                        EKF.x[12][0] = quats[3];
                        cout << "q0: " << EKF.x[9][0] << " q1: " << EKF.x[10][0] << " q2: " << EKF.x[11][0] << " q3: " << EKF.x[12][0] << endl;
                        attitude_determined = true;
                    }
                    cout << "Case 5 \n";
                    break;

            }

            if (step == 0) {
                prev_timestamp = curr_timestamp;
                step++;
                continue;
            }
            dt = (curr_timestamp - prev_timestamp) * 1e-6;
            // Clamp dt to avoid numerical issues
            if (dt < 1e-5) dt = 1e-5;
            if (dt > 0.05) dt = 0.05;
            prev_timestamp = curr_timestamp;
            // cout << "CURRENT TIMESTAMP: " << curr_timestamp << endl;
            t = curr_timestamp*1e-6;
            cout << "t: " << t << endl;
            // Thrust starts at 3006.713631
            if (attitude_determined){
                // Check for NaN/Inf in state and covariance
                bool state_valid = true;
                for (const auto& row : EKF.x) for (const auto& v : row) if (isnan(v) || isinf(v)) state_valid = false;
                for (const auto& row : EKF.P) for (const auto& v : row) if (isnan(v) || isinf(v)) state_valid = false;
                if (!state_valid) {
                    std::cerr << "State or covariance became NaN/Inf, skipping update at t=" << t << std::endl;
                    break;
                }
                // Simulation logic using parsed values
                thr = interpolate_thrust(t); // for real data use -3006.713631
                cout << "Thrust: " << thr << endl;
                SoS = calculateSoS(gamma0, R_air, T0);
                mach = calculateMachNumber(magnitude(vector<double>{EKF.x[3][0], EKF.x[4][0], EKF.x[5][0]}), SoS);
                tie(cd, cna) = lookupDrag(mach,dragData);
                // Use curr_timestamp, curr_sensor_id, curr_readings as needed here
                EKF.predict(thr, cd, area, rho, mass0, gravity, dt);
                // if (t > 3006.713631){
                //     EKF.predict(thr, cd, area, rho, mass0, gravity, dt);
                // }
                // else{
                //     EKF.predict(thr, cd, area, rho, mass0, 0, dt);
                // }
                q_mag = magnitude({EKF.x[9][0], EKF.x[10][0], EKF.x[11][0], EKF.x[12][0]});
                EKF.x[9][0] = EKF.x[9][0]/q_mag;
                EKF.x[10][0] = EKF.x[10][0]/q_mag;
                EKF.x[11][0] = EKF.x[11][0]/q_mag;
                EKF.x[12][0] = EKF.x[12][0]/q_mag;
                cout << "Predict:\n";
                cout << "dt: " << dt << endl;

                
                // if (curr_sensor_id == 2 || curr_sensor_id == 3){
                    EKF.printKF();
                    EKF.update(curr_sensor_id, z);
                    q_mag = magnitude({EKF.x[9][0], EKF.x[10][0], EKF.x[11][0], EKF.x[12][0]});
                    EKF.x[9][0] = EKF.x[9][0]/q_mag;
                    EKF.x[10][0] = EKF.x[10][0]/q_mag;
                    EKF.x[11][0] = EKF.x[11][0]/q_mag;
                    EKF.x[12][0] = EKF.x[12][0]/q_mag;
                    cout << "Update:\n";
                    // EKF.printKF();
                    update_count++;
                    // if (update_count>10) break;
                // }
                vector<double> line({t,EKF.x[0][0],EKF.x[1][0],EKF.x[2][0],EKF.x[3][0],EKF.x[4][0],EKF.x[5][0],EKF.x[6][0],EKF.x[7][0],EKF.x[8][0],EKF.x[9][0],EKF.x[10][0],EKF.x[11][0],EKF.x[12][0],EKF.x[13][0],EKF.x[14][0],EKF.x[15][0],EKF.x[16][0],double(curr_sensor_id)});
                writeLineToCSV("rocketEKFtest_data8.csv", line);
                
                step++;
                if (isnan(EKF.x[0][0])) {
                    cout << "Hit a Nan\n";
                    break;
                }
                
            }
        }

    }
}